# IAR project Backup of Project.ewp, settings and files
configuration B-L475E-IOT01 (ARM)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; BAIDU; USE_HAL_DRIVER; EINVAL=-1; ENOMEM=EINVAL; REFCOUNT_ATOMIC_DONTCARE=1; MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>; ENABLE_IOT_ERROR; ENABLE_IOT_INFO; ENABLE_IOT_WARNING; SENSOR; USE_MBED_TLS; USE_WIFI; AZURE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers/BSP/B-L475E-IOT01; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers/BSP/Components/lps22hb; ..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x; ..\..\..\WiFi\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\es_wifi; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\umqtt\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\parson; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\Inc; ..\..\..\..\..\Common\AWS\Inc; ..\..\..\..\..\Common\Baidu\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Azure.bin
  ILINK.IlinkOutputFile: B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Baidu
    ../../../../../Common/Baidu/Src/: az_platform_STM32Cube.c az_threadapi_STM32Cube.c az_tickcounter_STM32Cube.c az_tlsio_mbedtls_STM32Cube.c azure_base64.c azure_sha1.c azure_version.c iothub_mqtt_client_sample.c socketio_STM32Cube.c tcpsocketSTM32Cube.c
  group Application/Common
    ../../../../../Common/AWS/Src/: cloud.c entropy_hardware_poll.c heap.c http_util.c iot_flash_config.c lwip_net.c mbedtls_net.c net.c net_tcp_lwip.c net_tcp_wifi.c net_tls_mbedtls.c rfu.c sensors_data.c STM32CubeRTCInterface.c timedate.c timingSystem.c wifi_net.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: flash_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c vl53l0x_platform.c vl53l0x_proximity.c
  group Application/WiFi
    ../../../WiFi/Src/: es_wifi_io.c wifi.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Middlewares/baidu/c-utility
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/src/: base64.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gb_rand.c gb_stdio.c gb_time.c gballoc.c hmac.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha1.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c tlsio_cyclonessl.c tlsio_cyclonessl_socket.c tlsio_cyclonessl_socket_bsd.c tlsio_openssl.c tlsio_schannel.c tlsio_wolfssl.c urlencode.c usha.c utf8_checker.c uws_client.c uws_frame_encoder.c vector.c wsio.c x509_openssl.c x509_schannel.c xio.c xlogging.c
  group Middlewares/baidu/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/adapters/: agenttime.c
  group Middlewares/baidu/iothub_client
    ../../../../../../Middlewares/Third_Party/baidu/iothub_client/src/: certs.c iotdm_client.c iothub_client_persistence.c iothub_client_retry_control.c iothub_mqtt_client.c version.c
  group Middlewares/baidu/parson
    ../../../../../../Middlewares/Third_Party/baidu/parson/: parson.c
  group Middlewares/baidu/serializer
    ../../../../../../Middlewares/Third_Party/baidu/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c schemaserializer.c
  group Middlewares/baidu/umqtt
    ../../../../../../Middlewares/Third_Party/baidu/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets_template.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
