# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x0807FFFF-0x1FFFFFFE) IRAM2(0x20017FFF-0x100003FE) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,BAIDU,USE_HAL_DRIVER,EINVAL=-1,ENOMEM=EINVAL,REFCOUNT_ATOMIC_DONTCARE=1,MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>,ENABLE_IOT_ERROR,ENABLE_IOT_INFO,ENABLE_IOT_WARNING,SENSOR,USE_MBED_TLS,USE_WIFI,AZURE
  c misc: --gnu
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Middlewares/Third_Party/baidu/umqtt/inc;../../../../../../Middlewares/Third_Party/baidu/iothub_client/inc;../../../../../../Middlewares/Third_Party/baidu/c-utility/inc;../../../../../../Middlewares/Third_Party/baidu/serializer/inc;../../../../../../Middlewares/Third_Party/baidu/parson;../../../../../../Middlewares/Third_Party/mbedTLS/include;../Inc;../../../../../Common/Shared/Inc;../../../../../Common/Baidu/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/WiFi
    ../Src/: tcpsocketSTM32Cube.c es_wifi_io.c wifi.c
  group Application/Baidu
    ../../../../../Common/Baidu/Src/: az_platform_STM32Cube.c socketio_STM32Cube.c az_tlsio_mbedtls_STM32Cube.c baidu_base64.c az_tickcounter_STM32Cube.c baidu_sha1.c az_threadapi_STM32Cube.c
  group Doc
    ../: readme-wifi-package.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rng.c
  group Application/Shared
    ../../../../../Common/Shared/Src/: STM32CubeRTCInterface.c cloud.c http_util.c heap.c net_tcp_lwip.c mbedtls_net.c timedate.c lwip_net.c sensors_data.c wifi_net.c net.c iot_flash_config.c rfu.c net_tcp_wifi.c flash_l4.c timingSystem.c net_tls_mbedtls.c entropy_hardware_poll.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets_template.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/baidu/c-utility
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/src/: optionhandler.c sha384-512.c vector.c consolelogger.c utf8_checker.c doublylinkedlist.c sha1.c x509_schannel.c urlencode.c string_tokenizer.c uws_client.c x509_openssl.c xlogging.c xio.c strings.c sha224.c buffer.c tlsio_cyclonessl.c gb_time.c tlsio_openssl.c http_proxy_io.c wsio.c hmac.c connection_string_parser.c uws_frame_encoder.c tlsio_cyclonessl_socket_bsd.c singlylinkedlist.c tlsio_schannel.c gb_stdio.c gballoc.c httpapiexsas.c httpapiex.c hmacsha256.c tlsio_wolfssl.c tlsio_cyclonessl_socket.c constbuffer.c httpheaders.c map.c crt_abstractions.c gb_rand.c usha.c constmap.c base64.c sastoken.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_platform_log.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_tsensor.c stm32l475e_iot01_psensor.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_accelero.c stm32l475e_iot01.c stm32l475e_iot01_gyro.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Middlewares/baidu/serializer
    ../../../../../../Middlewares/Third_Party/baidu/serializer/src/: schemaserializer.c dataserializer.c datamarshaller.c codefirst.c schemalib.c commanddecoder.c iotdevice.c schema.c methodreturn.c jsondecoder.c agenttypesystem.c datapublisher.c jsonencoder.c multitree.c
  group Application/User
    ../Src/: vl53l0x_proximity.c vl53l0x_platform.c stm32l4xx_hal_msp.c stm32l4xx_it.c iothub_mqtt_client_wifi_sample.c main.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Middlewares/baidu/parson
    ../../../../../../Middlewares/Third_Party/baidu/parson/: parson.c
  group Middlewares/baidu/umqtt
    ../../../../../../Middlewares/Third_Party/baidu/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/baidu/iothub_client
    ../../../../../../Middlewares/Third_Party/baidu/iothub_client/src/: version.c iothub_client_retry_control.c certs.c iothub_client_persistence.c iotdm_client.c iothub_mqtt_client.c
  group Middlewares/baidu/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/adapters/: agenttime.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
