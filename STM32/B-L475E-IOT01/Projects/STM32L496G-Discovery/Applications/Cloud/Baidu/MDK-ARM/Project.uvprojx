# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,_UINTPTR_T,USE_C2C,BAIDU,AZURE,EINVAL=22,ENOMEM=12
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/ug96;../../../../../../Middlewares/Third_Party/baidu/certs;../../../../../../Middlewares/Third_Party/baidu/c-utility/inc;../../../../../../Middlewares/Third_Party/baidu/iothub_client/inc;../../../../../../Middlewares/Third_Party/baidu/parson;../../../../../../Middlewares/Third_Party/baidu/serializer/inc;../../../../../../Middlewares/Third_Party/baidu/umqtt/inc;../../../../../Common/Baidu/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Project.sct
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/C2C
    ../Src/: c2c.c ug96_io.c tcpsocketSTM32Cube.c
  group Doc
    ../: readme-c2c-package.txt
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Middlewares/Third_Party/baidu/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/baidu/parson
    ../../../../../../Middlewares/Third_Party/baidu/parson/: parson.c
  group Application/Shared
    ../../../../../Common/Shared/Src/: timingSystem.c heap.c rfu.c c2c_net.c STM32CubeRTCInterface.c net.c mbedtls_patch.c timer.c cloud.c http_util.c mbedtls_net.c timedate.c net_tls_mbedtls.c net_tcp_c2c.c flash_l4.c entropy_hardware_poll.c iot_flash_config.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c iothub_mqtt_client_c2c_sample.c main.c
  group Middlewares/Third_Party/baidu/umqtt
    ../../../../../../Middlewares/Third_Party/baidu/umqtt/src/: mqtt_codec.c mqtt_message.c mqtt_client.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_nand.c stm32l4xx_hal_pwr.c stm32l4xx_hal_dac.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_hash.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c.c stm32l4xx_hal_usart.c stm32l4xx_hal_can.c stm32l4xx_hal_uart.c stm32l4xx_hal_cryp.c stm32l4xx_hal_rng.c stm32l4xx_hal_dma.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_nor.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_qspi.c
  group Middlewares/Third_Party/baidu/c-utility
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/src/: constbuffer.c gballoc.c doublylinkedlist.c httpapiex.c singlylinkedlist.c sastoken.c httpheaders.c utf8_checker.c hmac.c urlencode.c optionhandler.c strings.c crt_abstractions.c xio.c http_proxy_io.c vector.c uws_frame_encoder.c usha.c httpapiexsas.c gb_stdio.c gb_rand.c hmacsha256.c uws_client.c sha384-512.c map.c xlogging.c connection_string_parser.c buffer.c sha224.c constmap.c wsio.c gb_time.c consolelogger.c string_tokenizer.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Middlewares/Third_Party/baidu/iothub_client
    ../../../../../../Middlewares/Third_Party/baidu/iothub_client/src/: iotdm_client.c iothub_mqtt_client.c iothub_client_persistence.c iothub_client_retry_control.c
  group Middlewares/Third_Party/baidu/serializer
    ../../../../../../Middlewares/Third_Party/baidu/serializer/src/: jsondecoder.c commanddecoder.c schemaserializer.c iotdevice.c agenttypesystem.c multitree.c dataserializer.c codefirst.c schema.c jsonencoder.c schemalib.c methodreturn.c datapublisher.c datamarshaller.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: entropy.c sha256.c ssl_ticket.c memory_buffer_alloc.c version.c ssl_cache.c base64.c pkcs11.c timing.c certs.c havege.c ccm.c ssl_ciphersuites.c blowfish.c gcm.c x509_csr.c x509write_crt.c x509_crt.c x509.c ssl_srv.c md5.c ctr_drbg.c aes.c cipher_wrap.c ssl_cookie.c asn1parse.c net_sockets_template.c pk.c cipher.c arc4.c padlock.c cmac.c sha512.c error.c camellia.c md2.c md_wrap.c pkcs12.c bignum.c ssl_cli.c debug.c aesni.c threading.c pkcs5.c sha1.c ecdh.c ripemd160.c md.c ecjpake.c x509_create.c pkwrite.c pkparse.c xtea.c asn1write.c ecdsa.c x509_crl.c x509write_csr.c ecp_curves.c des.c ssl_tls.c ecp.c hmac_drbg.c md4.c platform.c rsa.c version_features.c entropy_poll.c pem.c oid.c pk_wrap.c dhm.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Application/Baidu
    ../../../../../Common/Baidu/Src/: baidu_base64.c az_tlsio_mbedtls_STM32Cube.c az_platform_STM32Cube.c az_tickcounter_STM32Cube.c baidu_sha1.c az_threadapi_STM32Cube.c baidu_certs.c socketio_STM32Cube.c
software components: CMSIS:CORE 5.0.1
