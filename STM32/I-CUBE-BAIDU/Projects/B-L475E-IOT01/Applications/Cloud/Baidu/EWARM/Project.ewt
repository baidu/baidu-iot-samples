<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>B-L475E-IOT01</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>0</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>0</enableParallel>
                    <parallelThreads>2</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.0</cstat_version>
                    <checks_tree>
                        <package enabled="true" name="STDCHECKS">
                            <group enabled="true" name="ARR">
                                <check enabled="true" name="ARR-inv-index-pos" />
                                <check enabled="true" name="ARR-inv-index-ptr-pos" />
                                <check enabled="true" name="ARR-inv-index-ptr" />
                                <check enabled="true" name="ARR-inv-index" />
                                <check enabled="true" name="ARR-neg-index" />
                                <check enabled="true" name="ARR-uninit-index" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check enabled="true" name="ATH-cmp-float" />
                                <check enabled="true" name="ATH-cmp-unsign-neg" />
                                <check enabled="true" name="ATH-cmp-unsign-pos" />
                                <check enabled="true" name="ATH-div-0-assign" />
                                <check enabled="false" name="ATH-div-0-cmp-aft" />
                                <check enabled="true" name="ATH-div-0-cmp-bef" />
                                <check enabled="true" name="ATH-div-0-interval" />
                                <check enabled="true" name="ATH-div-0-pos" />
                                <check enabled="true" name="ATH-div-0-unchk-global" />
                                <check enabled="true" name="ATH-div-0-unchk-local" />
                                <check enabled="true" name="ATH-div-0-unchk-param" />
                                <check enabled="true" name="ATH-div-0" />
                                <check enabled="true" name="ATH-inc-bool" />
                                <check enabled="true" name="ATH-malloc-overrun" />
                                <check enabled="true" name="ATH-neg-check-nonneg" />
                                <check enabled="true" name="ATH-neg-check-pos" />
                                <check enabled="true" name="ATH-new-overrun" />
                                <check enabled="false" name="ATH-overflow-cast" />
                                <check enabled="true" name="ATH-overflow" />
                                <check enabled="true" name="ATH-shift-bounds" />
                                <check enabled="true" name="ATH-shift-neg" />
                                <check enabled="true" name="ATH-sizeof-by-sizeof" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check enabled="false" name="CAST-old-style" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check enabled="true" name="CATCH-object-slicing" />
                                <check enabled="false" name="CATCH-xtor-bad-member" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check enabled="false" name="COMMA-overload" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check enabled="true" name="COMMENT-nested" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check enabled="true" name="CONST-member-ret" />
                            </group>
                            <group enabled="true" name="COP">
                                <check enabled="false" name="COP-alloc-ctor" />
                                <check enabled="true" name="COP-assign-op-ret" />
                                <check enabled="true" name="COP-assign-op-self" />
                                <check enabled="true" name="COP-assign-op" />
                                <check enabled="true" name="COP-copy-ctor" />
                                <check enabled="false" name="COP-dealloc-dtor" />
                                <check enabled="true" name="COP-dtor-throw" />
                                <check enabled="true" name="COP-dtor" />
                                <check enabled="true" name="COP-init-order" />
                                <check enabled="true" name="COP-init-uninit" />
                                <check enabled="true" name="COP-member-uninit" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check enabled="true" name="CPU-ctor-call-virt" />
                                <check enabled="false" name="CPU-ctor-implicit" />
                                <check enabled="true" name="CPU-delete-throw" />
                                <check enabled="true" name="CPU-delete-void" />
                                <check enabled="true" name="CPU-dtor-call-virt" />
                                <check enabled="true" name="CPU-malloc-class" />
                                <check enabled="true" name="CPU-nonvirt-dtor" />
                                <check enabled="true" name="CPU-return-ref-to-class-data" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check enabled="false" name="DECL-implicit-int" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check enabled="true" name="DEFINE-hash-multiple" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check enabled="false" name="ENUM-bounds" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check enabled="true" name="EXP-cond-assign" />
                                <check enabled="true" name="EXP-dangling-else" />
                                <check enabled="true" name="EXP-loop-exit" />
                                <check enabled="false" name="EXP-main-ret-int" />
                                <check enabled="false" name="EXP-null-stmt" />
                                <check enabled="false" name="EXP-stray-semicolon" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check enabled="true" name="EXPR-const-overflow" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check enabled="true" name="FPT-cmp-null" />
                                <check enabled="false" name="FPT-literal" />
                                <check enabled="true" name="FPT-misuse" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check enabled="false" name="FUNC-implicit-decl" />
                                <check enabled="false" name="FUNC-unprototyped-all" />
                                <check enabled="true" name="FUNC-unprototyped-used" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check enabled="false" name="INCLUDE-c-file" />
                            </group>
                            <group enabled="true" name="INT">
                                <check enabled="false" name="INT-use-signed-as-unsigned-pos" />
                                <check enabled="true" name="INT-use-signed-as-unsigned" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check enabled="true" name="ITR-end-cmp-aft" />
                                <check enabled="true" name="ITR-end-cmp-bef" />
                                <check enabled="true" name="ITR-invalidated" />
                                <check enabled="false" name="ITR-mismatch-alg" />
                                <check enabled="false" name="ITR-store" />
                                <check enabled="true" name="ITR-uninit" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check enabled="false" name="LIB-bsearch-overrun-pos" />
                                <check enabled="false" name="LIB-bsearch-overrun" />
                                <check enabled="false" name="LIB-fn-unsafe" />
                                <check enabled="false" name="LIB-fread-overrun-pos" />
                                <check enabled="true" name="LIB-fread-overrun" />
                                <check enabled="false" name="LIB-memchr-overrun-pos" />
                                <check enabled="true" name="LIB-memchr-overrun" />
                                <check enabled="false" name="LIB-memcpy-overrun-pos" />
                                <check enabled="true" name="LIB-memcpy-overrun" />
                                <check enabled="false" name="LIB-memset-overrun-pos" />
                                <check enabled="true" name="LIB-memset-overrun" />
                                <check enabled="false" name="LIB-putenv" />
                                <check enabled="false" name="LIB-qsort-overrun-pos" />
                                <check enabled="false" name="LIB-qsort-overrun" />
                                <check enabled="true" name="LIB-return-const" />
                                <check enabled="true" name="LIB-return-error" />
                                <check enabled="true" name="LIB-return-leak" />
                                <check enabled="true" name="LIB-return-neg" />
                                <check enabled="true" name="LIB-return-null" />
                                <check enabled="false" name="LIB-sprintf-overrun" />
                                <check enabled="false" name="LIB-std-sort-overrun-pos" />
                                <check enabled="true" name="LIB-std-sort-overrun" />
                                <check enabled="false" name="LIB-strcat-overrun-pos" />
                                <check enabled="true" name="LIB-strcat-overrun" />
                                <check enabled="false" name="LIB-strcpy-overrun-pos" />
                                <check enabled="true" name="LIB-strcpy-overrun" />
                                <check enabled="false" name="LIB-strncat-overrun-pos" />
                                <check enabled="true" name="LIB-strncat-overrun" />
                                <check enabled="false" name="LIB-strncmp-overrun-pos" />
                                <check enabled="true" name="LIB-strncmp-overrun" />
                                <check enabled="false" name="LIB-strncpy-overrun-pos" />
                                <check enabled="true" name="LIB-strncpy-overrun" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check enabled="false" name="LOGIC-overload" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check enabled="true" name="MEM-delete-array-op" />
                                <check enabled="true" name="MEM-delete-op" />
                                <check enabled="true" name="MEM-double-free-alias" />
                                <check enabled="true" name="MEM-double-free-some" />
                                <check enabled="true" name="MEM-double-free" />
                                <check enabled="true" name="MEM-free-field" />
                                <check enabled="true" name="MEM-free-fptr" />
                                <check enabled="false" name="MEM-free-no-alloc-struct" />
                                <check enabled="false" name="MEM-free-no-alloc" />
                                <check enabled="true" name="MEM-free-no-use" />
                                <check enabled="true" name="MEM-free-op" />
                                <check enabled="true" name="MEM-free-struct-field" />
                                <check enabled="true" name="MEM-free-variable-alias" />
                                <check enabled="true" name="MEM-free-variable" />
                                <check enabled="true" name="MEM-leak-alias" />
                                <check enabled="false" name="MEM-leak" />
                                <check enabled="false" name="MEM-malloc-arith" />
                                <check enabled="true" name="MEM-malloc-diff-type" />
                                <check enabled="true" name="MEM-malloc-sizeof-ptr" />
                                <check enabled="true" name="MEM-malloc-sizeof" />
                                <check enabled="false" name="MEM-malloc-strlen" />
                                <check enabled="true" name="MEM-realloc-diff-type" />
                                <check enabled="true" name="MEM-return-free" />
                                <check enabled="true" name="MEM-return-no-assign" />
                                <check enabled="true" name="MEM-stack-global-field" />
                                <check enabled="true" name="MEM-stack-global" />
                                <check enabled="true" name="MEM-stack-param-ref" />
                                <check enabled="true" name="MEM-stack-param" />
                                <check enabled="true" name="MEM-stack-pos" />
                                <check enabled="true" name="MEM-stack-ref" />
                                <check enabled="true" name="MEM-stack" />
                                <check enabled="true" name="MEM-use-free-all" />
                                <check enabled="true" name="MEM-use-free-some" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check enabled="true" name="PTR-arith-field" />
                                <check enabled="true" name="PTR-arith-stack" />
                                <check enabled="true" name="PTR-arith-var" />
                                <check enabled="true" name="PTR-cmp-str-lit" />
                                <check enabled="false" name="PTR-null-assign-fun-pos" />
                                <check enabled="false" name="PTR-null-assign-pos" />
                                <check enabled="true" name="PTR-null-assign" />
                                <check enabled="true" name="PTR-null-cmp-aft" />
                                <check enabled="true" name="PTR-null-cmp-bef-fun" />
                                <check enabled="true" name="PTR-null-cmp-bef" />
                                <check enabled="true" name="PTR-null-fun-pos" />
                                <check enabled="false" name="PTR-null-literal-pos" />
                                <check enabled="false" name="PTR-overload" />
                                <check enabled="false" name="PTR-singleton-arith-pos" />
                                <check enabled="true" name="PTR-singleton-arith" />
                                <check enabled="true" name="PTR-unchk-param-some" />
                                <check enabled="false" name="PTR-unchk-param" />
                                <check enabled="false" name="PTR-uninit-pos" />
                                <check enabled="true" name="PTR-uninit" />
                            </group>
                            <group enabled="true" name="RED">
                                <check enabled="false" name="RED-alloc-zero-bytes" />
                                <check enabled="false" name="RED-case-reach" />
                                <check enabled="false" name="RED-cmp-always" />
                                <check enabled="false" name="RED-cmp-never" />
                                <check enabled="false" name="RED-cond-always" />
                                <check enabled="true" name="RED-cond-const-assign" />
                                <check enabled="false" name="RED-cond-const-expr" />
                                <check enabled="false" name="RED-cond-const" />
                                <check enabled="false" name="RED-cond-never" />
                                <check enabled="true" name="RED-dead" />
                                <check enabled="false" name="RED-expr" />
                                <check enabled="false" name="RED-func-no-effect" />
                                <check enabled="true" name="RED-local-hides-global" />
                                <check enabled="false" name="RED-local-hides-local" />
                                <check enabled="false" name="RED-local-hides-member" />
                                <check enabled="true" name="RED-local-hides-param" />
                                <check enabled="false" name="RED-no-effect" />
                                <check enabled="true" name="RED-self-assign" />
                                <check enabled="true" name="RED-unused-assign" />
                                <check enabled="false" name="RED-unused-param" />
                                <check enabled="false" name="RED-unused-return-val" />
                                <check enabled="false" name="RED-unused-val" />
                                <check enabled="true" name="RED-unused-var-all" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check enabled="false" name="RESOURCE-deref-file" />
                                <check enabled="true" name="RESOURCE-double-close" />
                                <check enabled="true" name="RESOURCE-file-no-close-all" />
                                <check enabled="false" name="RESOURCE-file-pos-neg" />
                                <check enabled="true" name="RESOURCE-file-use-after-close" />
                                <check enabled="false" name="RESOURCE-implicit-deref-file" />
                                <check enabled="true" name="RESOURCE-write-ronly-file" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check enabled="true" name="SIZEOF-side-effect" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check enabled="true" name="SPC-order" />
                                <check enabled="false" name="SPC-uninit-arr-all" />
                                <check enabled="true" name="SPC-uninit-struct-field-heap" />
                                <check enabled="false" name="SPC-uninit-struct-field" />
                                <check enabled="true" name="SPC-uninit-struct" />
                                <check enabled="true" name="SPC-uninit-var-all" />
                                <check enabled="true" name="SPC-uninit-var-some" />
                                <check enabled="false" name="SPC-volatile-reads" />
                                <check enabled="false" name="SPC-volatile-writes" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check enabled="false" name="STRUCT-signed-bit" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check enabled="true" name="SWITCH-fall-through" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check enabled="false" name="THROW-empty" />
                                <check enabled="false" name="THROW-main" />
                                <check enabled="true" name="THROW-null" />
                                <check enabled="true" name="THROW-ptr" />
                                <check enabled="true" name="THROW-static" />
                                <check enabled="true" name="THROW-unhandled" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check enabled="true" name="UNION-overlap-assign" />
                                <check enabled="true" name="UNION-type-punning" />
                            </group>
                        </package>
                        <package enabled="false" name="CERT">
                            <group enabled="true" name="CERT-EXP">
                                <check enabled="true" name="CERT-EXP19-C" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check enabled="true" name="CERT-FIO37-C" />
                                <check enabled="true" name="CERT-FIO38-C" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check enabled="true" name="CERT-SIG31-C" />
                            </group>
                        </package>
                        <package enabled="false" name="SECURITY">
                            <group enabled="true" name="SEC-BUFFER">
                                <check enabled="true" name="SEC-BUFFER-memory-leak-alias" />
                                <check enabled="false" name="SEC-BUFFER-memory-leak" />
                                <check enabled="false" name="SEC-BUFFER-memset-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-memset-overrun" />
                                <check enabled="false" name="SEC-BUFFER-qsort-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-qsort-overrun" />
                                <check enabled="true" name="SEC-BUFFER-sprintf-overrun" />
                                <check enabled="false" name="SEC-BUFFER-std-sort-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-std-sort-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strcat-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strcat-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strcpy-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strcpy-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncat-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncat-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncmp-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncmp-overrun" />
                                <check enabled="false" name="SEC-BUFFER-strncpy-overrun-pos" />
                                <check enabled="true" name="SEC-BUFFER-strncpy-overrun" />
                                <check enabled="true" name="SEC-BUFFER-tainted-alloc-size" />
                                <check enabled="true" name="SEC-BUFFER-tainted-copy-length" />
                                <check enabled="true" name="SEC-BUFFER-tainted-copy" />
                                <check enabled="true" name="SEC-BUFFER-tainted-index" />
                                <check enabled="true" name="SEC-BUFFER-tainted-offset" />
                                <check enabled="true" name="SEC-BUFFER-use-after-free-all" />
                                <check enabled="true" name="SEC-BUFFER-use-after-free-some" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check enabled="true" name="SEC-DIV-0-compare-after" />
                                <check enabled="true" name="SEC-DIV-0-compare-before" />
                                <check enabled="true" name="SEC-DIV-0-tainted" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check enabled="true" name="SEC-FILEOP-open-no-close" />
                                <check enabled="false" name="SEC-FILEOP-path-traversal" />
                                <check enabled="true" name="SEC-FILEOP-use-after-close" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check enabled="false" name="SEC-INJECTION-sql" />
                                <check enabled="false" name="SEC-INJECTION-xpath" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check enabled="true" name="SEC-LOOP-tainted-bound" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check enabled="false" name="SEC-NULL-assignment-fun-pos" />
                                <check enabled="true" name="SEC-NULL-assignment" />
                                <check enabled="true" name="SEC-NULL-cmp-aft" />
                                <check enabled="true" name="SEC-NULL-cmp-bef-fun" />
                                <check enabled="true" name="SEC-NULL-cmp-bef" />
                                <check enabled="false" name="SEC-NULL-literal-pos" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check enabled="true" name="SEC-STRING-format-string" />
                                <check enabled="false" name="SEC-STRING-hard-coded-credentials" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC2004">
                            <group enabled="true" name="MISRAC2004-1">
                                <check enabled="true" name="MISRAC2004-1.1" />
                                <check enabled="true" name="MISRAC2004-1.2_a" />
                                <check enabled="true" name="MISRAC2004-1.2_b" />
                                <check enabled="true" name="MISRAC2004-1.2_c" />
                                <check enabled="true" name="MISRAC2004-1.2_d" />
                                <check enabled="true" name="MISRAC2004-1.2_e" />
                                <check enabled="true" name="MISRAC2004-1.2_f" />
                                <check enabled="true" name="MISRAC2004-1.2_g" />
                                <check enabled="true" name="MISRAC2004-1.2_h" />
                                <check enabled="true" name="MISRAC2004-1.2_i" />
                                <check enabled="true" name="MISRAC2004-1.2_j" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check enabled="true" name="MISRAC2004-2.1" />
                                <check enabled="true" name="MISRAC2004-2.2" />
                                <check enabled="true" name="MISRAC2004-2.3" />
                                <check enabled="false" name="MISRAC2004-2.4" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check enabled="true" name="MISRAC2004-5.2" />
                                <check enabled="true" name="MISRAC2004-5.3" />
                                <check enabled="true" name="MISRAC2004-5.4" />
                                <check enabled="false" name="MISRAC2004-5.5" />
                                <check enabled="false" name="MISRAC2004-5.6" />
                                <check enabled="false" name="MISRAC2004-5.7" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check enabled="true" name="MISRAC2004-6.1" />
                                <check enabled="true" name="MISRAC2004-6.2" />
                                <check enabled="false" name="MISRAC2004-6.3" />
                                <check enabled="true" name="MISRAC2004-6.4" />
                                <check enabled="true" name="MISRAC2004-6.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check enabled="true" name="MISRAC2004-7.1" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check enabled="true" name="MISRAC2004-8.1" />
                                <check enabled="true" name="MISRAC2004-8.2" />
                                <check enabled="true" name="MISRAC2004-8.3" />
                                <check enabled="true" name="MISRAC2004-8.5_a" />
                                <check enabled="true" name="MISRAC2004-8.5_b" />
                                <check enabled="true" name="MISRAC2004-8.6" />
                                <check enabled="true" name="MISRAC2004-8.7" />
                                <check enabled="true" name="MISRAC2004-8.8_a" />
                                <check enabled="true" name="MISRAC2004-8.8_b" />
                                <check enabled="false" name="MISRAC2004-8.9" />
                                <check enabled="true" name="MISRAC2004-8.12" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check enabled="true" name="MISRAC2004-8.10" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check enabled="true" name="MISRAC2004-9.1_a" />
                                <check enabled="true" name="MISRAC2004-9.1_b" />
                                <check enabled="true" name="MISRAC2004-9.1_c" />
                                <check enabled="true" name="MISRAC2004-9.2" />
                                <check enabled="true" name="MISRAC2004-9.3" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check enabled="true" name="MISRAC2004-10.1_a" />
                                <check enabled="true" name="MISRAC2004-10.1_b" />
                                <check enabled="true" name="MISRAC2004-10.1_c" />
                                <check enabled="true" name="MISRAC2004-10.1_d" />
                                <check enabled="true" name="MISRAC2004-10.2_a" />
                                <check enabled="true" name="MISRAC2004-10.2_b" />
                                <check enabled="true" name="MISRAC2004-10.2_c" />
                                <check enabled="true" name="MISRAC2004-10.2_d" />
                                <check enabled="true" name="MISRAC2004-10.3" />
                                <check enabled="true" name="MISRAC2004-10.4" />
                                <check enabled="true" name="MISRAC2004-10.5" />
                                <check enabled="true" name="MISRAC2004-10.6" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check enabled="true" name="MISRAC2004-11.1" />
                                <check enabled="false" name="MISRAC2004-11.3" />
                                <check enabled="false" name="MISRAC2004-11.4" />
                                <check enabled="true" name="MISRAC2004-11.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check enabled="false" name="MISRAC2004-12.1" />
                                <check enabled="true" name="MISRAC2004-12.2_a" />
                                <check enabled="true" name="MISRAC2004-12.2_b" />
                                <check enabled="true" name="MISRAC2004-12.2_c" />
                                <check enabled="true" name="MISRAC2004-12.3" />
                                <check enabled="true" name="MISRAC2004-12.4" />
                                <check enabled="true" name="MISRAC2004-12.5" />
                                <check enabled="false" name="MISRAC2004-12.6_a" />
                                <check enabled="false" name="MISRAC2004-12.6_b" />
                                <check enabled="true" name="MISRAC2004-12.7" />
                                <check enabled="true" name="MISRAC2004-12.8" />
                                <check enabled="true" name="MISRAC2004-12.9" />
                                <check enabled="true" name="MISRAC2004-12.10" />
                                <check enabled="false" name="MISRAC2004-12.11" />
                                <check enabled="true" name="MISRAC2004-12.12_a" />
                                <check enabled="true" name="MISRAC2004-12.12_b" />
                                <check enabled="false" name="MISRAC2004-12.13" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check enabled="true" name="MISRAC2004-13.1" />
                                <check enabled="false" name="MISRAC2004-13.2_a" />
                                <check enabled="false" name="MISRAC2004-13.2_b" />
                                <check enabled="false" name="MISRAC2004-13.2_c" />
                                <check enabled="false" name="MISRAC2004-13.2_d" />
                                <check enabled="false" name="MISRAC2004-13.2_e" />
                                <check enabled="true" name="MISRAC2004-13.3" />
                                <check enabled="true" name="MISRAC2004-13.4" />
                                <check enabled="true" name="MISRAC2004-13.5" />
                                <check enabled="true" name="MISRAC2004-13.6" />
                                <check enabled="true" name="MISRAC2004-13.7_a" />
                                <check enabled="true" name="MISRAC2004-13.7_b" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check enabled="true" name="MISRAC2004-14.1" />
                                <check enabled="true" name="MISRAC2004-14.2" />
                                <check enabled="true" name="MISRAC2004-14.3" />
                                <check enabled="true" name="MISRAC2004-14.4" />
                                <check enabled="true" name="MISRAC2004-14.5" />
                                <check enabled="true" name="MISRAC2004-14.6" />
                                <check enabled="true" name="MISRAC2004-14.7" />
                                <check enabled="true" name="MISRAC2004-14.8_a" />
                                <check enabled="true" name="MISRAC2004-14.8_b" />
                                <check enabled="true" name="MISRAC2004-14.8_c" />
                                <check enabled="true" name="MISRAC2004-14.8_d" />
                                <check enabled="true" name="MISRAC2004-14.9" />
                                <check enabled="true" name="MISRAC2004-14.10" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check enabled="true" name="MISRAC2004-15.0" />
                                <check enabled="true" name="MISRAC2004-15.1" />
                                <check enabled="true" name="MISRAC2004-15.2" />
                                <check enabled="true" name="MISRAC2004-15.3" />
                                <check enabled="true" name="MISRAC2004-15.4" />
                                <check enabled="true" name="MISRAC2004-15.5" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check enabled="true" name="MISRAC2004-16.1" />
                                <check enabled="true" name="MISRAC2004-16.2_a" />
                                <check enabled="true" name="MISRAC2004-16.2_b" />
                                <check enabled="true" name="MISRAC2004-16.3" />
                                <check enabled="true" name="MISRAC2004-16.4" />
                                <check enabled="true" name="MISRAC2004-16.5" />
                                <check enabled="true" name="MISRAC2004-16.7" />
                                <check enabled="true" name="MISRAC2004-16.8" />
                                <check enabled="true" name="MISRAC2004-16.9" />
                                <check enabled="true" name="MISRAC2004-16.10" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check enabled="true" name="MISRAC2004-17.1_a" />
                                <check enabled="true" name="MISRAC2004-17.1_b" />
                                <check enabled="true" name="MISRAC2004-17.1_c" />
                                <check enabled="true" name="MISRAC2004-17.2" />
                                <check enabled="true" name="MISRAC2004-17.3" />
                                <check enabled="true" name="MISRAC2004-17.4_a" />
                                <check enabled="true" name="MISRAC2004-17.4_b" />
                                <check enabled="true" name="MISRAC2004-17.5" />
                                <check enabled="true" name="MISRAC2004-17.6_a" />
                                <check enabled="true" name="MISRAC2004-17.6_b" />
                                <check enabled="true" name="MISRAC2004-17.6_c" />
                                <check enabled="true" name="MISRAC2004-17.6_d" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check enabled="true" name="MISRAC2004-18.1" />
                                <check enabled="true" name="MISRAC2004-18.2" />
                                <check enabled="true" name="MISRAC2004-18.4" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check enabled="false" name="MISRAC2004-19.1" />
                                <check enabled="false" name="MISRAC2004-19.2" />
                                <check enabled="true" name="MISRAC2004-19.4" />
                                <check enabled="true" name="MISRAC2004-19.5" />
                                <check enabled="true" name="MISRAC2004-19.6" />
                                <check enabled="false" name="MISRAC2004-19.7" />
                                <check enabled="true" name="MISRAC2004-19.10" />
                                <check enabled="true" name="MISRAC2004-19.12" />
                                <check enabled="false" name="MISRAC2004-19.13" />
                                <check enabled="true" name="MISRAC2004-19.15" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check enabled="true" name="MISRAC2004-20.1" />
                                <check enabled="true" name="MISRAC2004-20.2" />
                                <check enabled="true" name="MISRAC2004-20.3_a" />
                                <check enabled="true" name="MISRAC2004-20.3_b" />
                                <check enabled="true" name="MISRAC2004-20.3_c" />
                                <check enabled="true" name="MISRAC2004-20.3_d" />
                                <check enabled="true" name="MISRAC2004-20.3_e" />
                                <check enabled="true" name="MISRAC2004-20.3_f" />
                                <check enabled="true" name="MISRAC2004-20.3_g" />
                                <check enabled="true" name="MISRAC2004-20.3_h" />
                                <check enabled="true" name="MISRAC2004-20.3_i" />
                                <check enabled="true" name="MISRAC2004-20.4" />
                                <check enabled="true" name="MISRAC2004-20.5" />
                                <check enabled="true" name="MISRAC2004-20.6" />
                                <check enabled="true" name="MISRAC2004-20.7" />
                                <check enabled="true" name="MISRAC2004-20.8" />
                                <check enabled="true" name="MISRAC2004-20.9" />
                                <check enabled="true" name="MISRAC2004-20.10" />
                                <check enabled="true" name="MISRAC2004-20.11" />
                                <check enabled="true" name="MISRAC2004-20.12" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC2012">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check enabled="true" name="MISRAC2012-Dir-4.3" />
                                <check enabled="false" name="MISRAC2012-Dir-4.4" />
                                <check enabled="false" name="MISRAC2012-Dir-4.5" />
                                <check enabled="false" name="MISRAC2012-Dir-4.6_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.6_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.7_c" />
                                <check enabled="false" name="MISRAC2012-Dir-4.8" />
                                <check enabled="false" name="MISRAC2012-Dir-4.9" />
                                <check enabled="true" name="MISRAC2012-Dir-4.10" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_a" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_b" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_c" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_d" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_e" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_f" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_g" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_h" />
                                <check enabled="false" name="MISRAC2012-Dir-4.11_i" />
                                <check enabled="false" name="MISRAC2012-Dir-4.12" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_b" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_c" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_d" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_e" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_f" />
                                <check enabled="true" name="MISRAC2012-Dir-4.13_g" />
                                <check enabled="false" name="MISRAC2012-Dir-4.13_h" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check enabled="true" name="MISRAC2012-Rule-1.3_a" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_c" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_d" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_e" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_f" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_g" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_h" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_i" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_j" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_k" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_m" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_n" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_o" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_p" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_q" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_r" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_s" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_t" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_u" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_v" />
                                <check enabled="true" name="MISRAC2012-Rule-1.3_w" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check enabled="true" name="MISRAC2012-Rule-2.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-2.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-2.2_c" />
                                <check enabled="false" name="MISRAC2012-Rule-2.3" />
                                <check enabled="false" name="MISRAC2012-Rule-2.4" />
                                <check enabled="false" name="MISRAC2012-Rule-2.5" />
                                <check enabled="false" name="MISRAC2012-Rule-2.6" />
                                <check enabled="false" name="MISRAC2012-Rule-2.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check enabled="true" name="MISRAC2012-Rule-3.1" />
                                <check enabled="true" name="MISRAC2012-Rule-3.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check enabled="true" name="MISRAC2012-Rule-5.1" />
                                <check enabled="true" name="MISRAC2012-Rule-5.2_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.2_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.3_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.3_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.4_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.4_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.5_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-5.5_c99" />
                                <check enabled="true" name="MISRAC2012-Rule-5.6" />
                                <check enabled="true" name="MISRAC2012-Rule-5.7" />
                                <check enabled="true" name="MISRAC2012-Rule-5.8" />
                                <check enabled="false" name="MISRAC2012-Rule-5.9" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check enabled="true" name="MISRAC2012-Rule-6.1" />
                                <check enabled="true" name="MISRAC2012-Rule-6.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check enabled="true" name="MISRAC2012-Rule-7.1" />
                                <check enabled="true" name="MISRAC2012-Rule-7.2" />
                                <check enabled="true" name="MISRAC2012-Rule-7.3" />
                                <check enabled="true" name="MISRAC2012-Rule-7.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-7.4_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check enabled="true" name="MISRAC2012-Rule-8.1" />
                                <check enabled="true" name="MISRAC2012-Rule-8.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-8.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.4" />
                                <check enabled="false" name="MISRAC2012-Rule-8.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-8.5_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.6" />
                                <check enabled="false" name="MISRAC2012-Rule-8.7" />
                                <check enabled="false" name="MISRAC2012-Rule-8.9_a" />
                                <check enabled="false" name="MISRAC2012-Rule-8.9_b" />
                                <check enabled="true" name="MISRAC2012-Rule-8.10" />
                                <check enabled="false" name="MISRAC2012-Rule-8.11" />
                                <check enabled="true" name="MISRAC2012-Rule-8.12" />
                                <check enabled="false" name="MISRAC2012-Rule-8.13" />
                                <check enabled="true" name="MISRAC2012-Rule-8.14" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check enabled="true" name="MISRAC2012-Rule-9.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_c" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_d" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_e" />
                                <check enabled="true" name="MISRAC2012-Rule-9.1_f" />
                                <check enabled="true" name="MISRAC2012-Rule-9.2" />
                                <check enabled="true" name="MISRAC2012-Rule-9.3" />
                                <check enabled="true" name="MISRAC2012-Rule-9.4" />
                                <check enabled="true" name="MISRAC2012-Rule-9.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-9.5_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R2" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R3" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R4" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R5" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R6" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R7" />
                                <check enabled="true" name="MISRAC2012-Rule-10.1_R8" />
                                <check enabled="true" name="MISRAC2012-Rule-10.2" />
                                <check enabled="true" name="MISRAC2012-Rule-10.3" />
                                <check enabled="true" name="MISRAC2012-Rule-10.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-10.4_b" />
                                <check enabled="false" name="MISRAC2012-Rule-10.5" />
                                <check enabled="true" name="MISRAC2012-Rule-10.6" />
                                <check enabled="true" name="MISRAC2012-Rule-10.7" />
                                <check enabled="true" name="MISRAC2012-Rule-10.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check enabled="true" name="MISRAC2012-Rule-11.1" />
                                <check enabled="true" name="MISRAC2012-Rule-11.2" />
                                <check enabled="true" name="MISRAC2012-Rule-11.3" />
                                <check enabled="false" name="MISRAC2012-Rule-11.4" />
                                <check enabled="false" name="MISRAC2012-Rule-11.5" />
                                <check enabled="true" name="MISRAC2012-Rule-11.6" />
                                <check enabled="true" name="MISRAC2012-Rule-11.7" />
                                <check enabled="true" name="MISRAC2012-Rule-11.8" />
                                <check enabled="true" name="MISRAC2012-Rule-11.9" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check enabled="false" name="MISRAC2012-Rule-12.1" />
                                <check enabled="true" name="MISRAC2012-Rule-12.2" />
                                <check enabled="false" name="MISRAC2012-Rule-12.3" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check enabled="true" name="MISRAC2012-Rule-13.1" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-13.2_c" />
                                <check enabled="false" name="MISRAC2012-Rule-13.3" />
                                <check enabled="false" name="MISRAC2012-Rule-13.4_a" />
                                <check enabled="false" name="MISRAC2012-Rule-13.4_b" />
                                <check enabled="true" name="MISRAC2012-Rule-13.5" />
                                <check enabled="true" name="MISRAC2012-Rule-13.6" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check enabled="true" name="MISRAC2012-Rule-14.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.2" />
                                <check enabled="true" name="MISRAC2012-Rule-14.3_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.3_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_a" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_b" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_c" />
                                <check enabled="true" name="MISRAC2012-Rule-14.4_d" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check enabled="false" name="MISRAC2012-Rule-15.1" />
                                <check enabled="true" name="MISRAC2012-Rule-15.2" />
                                <check enabled="true" name="MISRAC2012-Rule-15.3" />
                                <check enabled="false" name="MISRAC2012-Rule-15.4" />
                                <check enabled="false" name="MISRAC2012-Rule-15.5" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_a" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_b" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_c" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_d" />
                                <check enabled="true" name="MISRAC2012-Rule-15.6_e" />
                                <check enabled="true" name="MISRAC2012-Rule-15.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check enabled="true" name="MISRAC2012-Rule-16.1" />
                                <check enabled="true" name="MISRAC2012-Rule-16.2" />
                                <check enabled="true" name="MISRAC2012-Rule-16.3" />
                                <check enabled="true" name="MISRAC2012-Rule-16.4" />
                                <check enabled="true" name="MISRAC2012-Rule-16.5" />
                                <check enabled="true" name="MISRAC2012-Rule-16.6" />
                                <check enabled="true" name="MISRAC2012-Rule-16.7" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check enabled="true" name="MISRAC2012-Rule-17.1" />
                                <check enabled="true" name="MISRAC2012-Rule-17.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-17.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-17.3" />
                                <check enabled="true" name="MISRAC2012-Rule-17.4" />
                                <check enabled="false" name="MISRAC2012-Rule-17.5" />
                                <check enabled="true" name="MISRAC2012-Rule-17.6" />
                                <check enabled="true" name="MISRAC2012-Rule-17.7" />
                                <check enabled="false" name="MISRAC2012-Rule-17.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check enabled="true" name="MISRAC2012-Rule-18.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_c" />
                                <check enabled="true" name="MISRAC2012-Rule-18.1_d" />
                                <check enabled="true" name="MISRAC2012-Rule-18.2" />
                                <check enabled="true" name="MISRAC2012-Rule-18.3" />
                                <check enabled="true" name="MISRAC2012-Rule-18.4" />
                                <check enabled="false" name="MISRAC2012-Rule-18.5" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_a" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_b" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_c" />
                                <check enabled="true" name="MISRAC2012-Rule-18.6_d" />
                                <check enabled="true" name="MISRAC2012-Rule-18.7" />
                                <check enabled="true" name="MISRAC2012-Rule-18.8" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check enabled="true" name="MISRAC2012-Rule-19.1" />
                                <check enabled="false" name="MISRAC2012-Rule-19.2" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check enabled="false" name="MISRAC2012-Rule-20.1" />
                                <check enabled="true" name="MISRAC2012-Rule-20.2" />
                                <check enabled="true" name="MISRAC2012-Rule-20.4_c89" />
                                <check enabled="true" name="MISRAC2012-Rule-20.4_c99" />
                                <check enabled="false" name="MISRAC2012-Rule-20.5" />
                                <check enabled="true" name="MISRAC2012-Rule-20.7" />
                                <check enabled="false" name="MISRAC2012-Rule-20.10" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check enabled="true" name="MISRAC2012-Rule-21.1" />
                                <check enabled="true" name="MISRAC2012-Rule-21.2" />
                                <check enabled="true" name="MISRAC2012-Rule-21.3" />
                                <check enabled="true" name="MISRAC2012-Rule-21.4" />
                                <check enabled="true" name="MISRAC2012-Rule-21.5" />
                                <check enabled="true" name="MISRAC2012-Rule-21.6" />
                                <check enabled="true" name="MISRAC2012-Rule-21.7" />
                                <check enabled="true" name="MISRAC2012-Rule-21.8" />
                                <check enabled="true" name="MISRAC2012-Rule-21.9" />
                                <check enabled="true" name="MISRAC2012-Rule-21.10" />
                                <check enabled="true" name="MISRAC2012-Rule-21.11" />
                                <check enabled="false" name="MISRAC2012-Rule-21.12_a" />
                                <check enabled="false" name="MISRAC2012-Rule-21.12_b" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check enabled="true" name="MISRAC2012-Rule-22.1_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.1_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.2_c" />
                                <check enabled="true" name="MISRAC2012-Rule-22.3" />
                                <check enabled="true" name="MISRAC2012-Rule-22.4" />
                                <check enabled="true" name="MISRAC2012-Rule-22.5_a" />
                                <check enabled="true" name="MISRAC2012-Rule-22.5_b" />
                                <check enabled="true" name="MISRAC2012-Rule-22.6" />
                            </group>
                        </package>
                        <package enabled="false" name="MISRAC++2008">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check enabled="true" name="MISRAC++2008-0-1-1" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_a" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_b" />
                                <check enabled="true" name="MISRAC++2008-0-1-2_c" />
                                <check enabled="true" name="MISRAC++2008-0-1-3" />
                                <check enabled="true" name="MISRAC++2008-0-1-4_a" />
                                <check enabled="true" name="MISRAC++2008-0-1-4_b" />
                                <check enabled="true" name="MISRAC++2008-0-1-6" />
                                <check enabled="true" name="MISRAC++2008-0-1-7" />
                                <check enabled="false" name="MISRAC++2008-0-1-8" />
                                <check enabled="true" name="MISRAC++2008-0-1-9" />
                                <check enabled="true" name="MISRAC++2008-0-1-11" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check enabled="true" name="MISRAC++2008-0-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check enabled="true" name="MISRAC++2008-0-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check enabled="true" name="MISRAC++2008-2-7-1" />
                                <check enabled="true" name="MISRAC++2008-2-7-2" />
                                <check enabled="false" name="MISRAC++2008-2-7-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check enabled="true" name="MISRAC++2008-2-10-1" />
                                <check enabled="true" name="MISRAC++2008-2-10-2" />
                                <check enabled="true" name="MISRAC++2008-2-10-3" />
                                <check enabled="true" name="MISRAC++2008-2-10-4" />
                                <check enabled="false" name="MISRAC++2008-2-10-5" />
                                <check enabled="true" name="MISRAC++2008-2-10-6" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check enabled="true" name="MISRAC++2008-2-13-2" />
                                <check enabled="true" name="MISRAC++2008-2-13-3" />
                                <check enabled="true" name="MISRAC++2008-2-13-4_a" />
                                <check enabled="true" name="MISRAC++2008-2-13-4_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check enabled="true" name="MISRAC++2008-3-1-1" />
                                <check enabled="true" name="MISRAC++2008-3-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check enabled="false" name="MISRAC++2008-3-9-2" />
                                <check enabled="true" name="MISRAC++2008-3-9-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check enabled="true" name="MISRAC++2008-4-5-1" />
                                <check enabled="true" name="MISRAC++2008-4-5-2" />
                                <check enabled="true" name="MISRAC++2008-4-5-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check enabled="true" name="MISRAC++2008-5-0-1_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-1_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-1_c" />
                                <check enabled="false" name="MISRAC++2008-5-0-2" />
                                <check enabled="true" name="MISRAC++2008-5-0-3" />
                                <check enabled="true" name="MISRAC++2008-5-0-4" />
                                <check enabled="true" name="MISRAC++2008-5-0-5" />
                                <check enabled="true" name="MISRAC++2008-5-0-6" />
                                <check enabled="true" name="MISRAC++2008-5-0-7" />
                                <check enabled="true" name="MISRAC++2008-5-0-8" />
                                <check enabled="true" name="MISRAC++2008-5-0-9" />
                                <check enabled="true" name="MISRAC++2008-5-0-10" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_c" />
                                <check enabled="true" name="MISRAC++2008-5-0-13_d" />
                                <check enabled="true" name="MISRAC++2008-5-0-14" />
                                <check enabled="true" name="MISRAC++2008-5-0-15_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-15_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_a" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_b" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_c" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_d" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_e" />
                                <check enabled="true" name="MISRAC++2008-5-0-16_f" />
                                <check enabled="true" name="MISRAC++2008-5-0-19" />
                                <check enabled="true" name="MISRAC++2008-5-0-21" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check enabled="true" name="MISRAC++2008-5-2-4" />
                                <check enabled="true" name="MISRAC++2008-5-2-5" />
                                <check enabled="true" name="MISRAC++2008-5-2-6" />
                                <check enabled="true" name="MISRAC++2008-5-2-7" />
                                <check enabled="false" name="MISRAC++2008-5-2-9" />
                                <check enabled="false" name="MISRAC++2008-5-2-10" />
                                <check enabled="true" name="MISRAC++2008-5-2-11_a" />
                                <check enabled="true" name="MISRAC++2008-5-2-11_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check enabled="true" name="MISRAC++2008-5-3-1" />
                                <check enabled="true" name="MISRAC++2008-5-3-2_a" />
                                <check enabled="true" name="MISRAC++2008-5-3-2_b" />
                                <check enabled="true" name="MISRAC++2008-5-3-3" />
                                <check enabled="true" name="MISRAC++2008-5-3-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check enabled="true" name="MISRAC++2008-5-8-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check enabled="true" name="MISRAC++2008-5-14-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check enabled="true" name="MISRAC++2008-5-18-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check enabled="false" name="MISRAC++2008-5-19-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check enabled="true" name="MISRAC++2008-6-2-1" />
                                <check enabled="true" name="MISRAC++2008-6-2-2" />
                                <check enabled="false" name="MISRAC++2008-6-2-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check enabled="true" name="MISRAC++2008-6-3-1_a" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_b" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_c" />
                                <check enabled="true" name="MISRAC++2008-6-3-1_d" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check enabled="true" name="MISRAC++2008-6-4-1" />
                                <check enabled="true" name="MISRAC++2008-6-4-2" />
                                <check enabled="true" name="MISRAC++2008-6-4-3" />
                                <check enabled="true" name="MISRAC++2008-6-4-4" />
                                <check enabled="true" name="MISRAC++2008-6-4-5" />
                                <check enabled="true" name="MISRAC++2008-6-4-6" />
                                <check enabled="true" name="MISRAC++2008-6-4-7" />
                                <check enabled="true" name="MISRAC++2008-6-4-8" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check enabled="true" name="MISRAC++2008-6-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-6-5-2" />
                                <check enabled="true" name="MISRAC++2008-6-5-3" />
                                <check enabled="true" name="MISRAC++2008-6-5-4" />
                                <check enabled="true" name="MISRAC++2008-6-5-6" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check enabled="true" name="MISRAC++2008-6-6-1" />
                                <check enabled="true" name="MISRAC++2008-6-6-2" />
                                <check enabled="true" name="MISRAC++2008-6-6-4" />
                                <check enabled="true" name="MISRAC++2008-6-6-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check enabled="true" name="MISRAC++2008-7-1-1" />
                                <check enabled="true" name="MISRAC++2008-7-1-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check enabled="true" name="MISRAC++2008-7-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check enabled="true" name="MISRAC++2008-7-4-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check enabled="true" name="MISRAC++2008-7-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-7-5-1_b" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_a" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_b" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_c" />
                                <check enabled="true" name="MISRAC++2008-7-5-2_d" />
                                <check enabled="false" name="MISRAC++2008-7-5-4_a" />
                                <check enabled="false" name="MISRAC++2008-7-5-4_b" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check enabled="true" name="MISRAC++2008-8-0-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check enabled="true" name="MISRAC++2008-8-4-1" />
                                <check enabled="true" name="MISRAC++2008-8-4-3" />
                                <check enabled="true" name="MISRAC++2008-8-4-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check enabled="true" name="MISRAC++2008-8-5-1_a" />
                                <check enabled="true" name="MISRAC++2008-8-5-1_b" />
                                <check enabled="true" name="MISRAC++2008-8-5-1_c" />
                                <check enabled="true" name="MISRAC++2008-8-5-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check enabled="true" name="MISRAC++2008-9-3-1" />
                                <check enabled="true" name="MISRAC++2008-9-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check enabled="true" name="MISRAC++2008-9-5-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check enabled="true" name="MISRAC++2008-9-6-2" />
                                <check enabled="true" name="MISRAC++2008-9-6-3" />
                                <check enabled="true" name="MISRAC++2008-9-6-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check enabled="true" name="MISRAC++2008-12-1-1_a" />
                                <check enabled="true" name="MISRAC++2008-12-1-1_b" />
                                <check enabled="true" name="MISRAC++2008-12-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check enabled="false" name="MISRAC++2008-15-0-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check enabled="true" name="MISRAC++2008-15-1-2" />
                                <check enabled="true" name="MISRAC++2008-15-1-3" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check enabled="true" name="MISRAC++2008-15-3-1" />
                                <check enabled="false" name="MISRAC++2008-15-3-2" />
                                <check enabled="true" name="MISRAC++2008-15-3-3" />
                                <check enabled="true" name="MISRAC++2008-15-3-4" />
                                <check enabled="true" name="MISRAC++2008-15-3-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check enabled="true" name="MISRAC++2008-15-5-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check enabled="true" name="MISRAC++2008-16-0-3" />
                                <check enabled="true" name="MISRAC++2008-16-0-4" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check enabled="true" name="MISRAC++2008-16-2-2" />
                                <check enabled="true" name="MISRAC++2008-16-2-3" />
                                <check enabled="true" name="MISRAC++2008-16-2-4" />
                                <check enabled="false" name="MISRAC++2008-16-2-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check enabled="true" name="MISRAC++2008-16-3-1" />
                                <check enabled="false" name="MISRAC++2008-16-3-2" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check enabled="true" name="MISRAC++2008-17-0-1" />
                                <check enabled="true" name="MISRAC++2008-17-0-3" />
                                <check enabled="true" name="MISRAC++2008-17-0-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check enabled="true" name="MISRAC++2008-18-0-1" />
                                <check enabled="true" name="MISRAC++2008-18-0-2" />
                                <check enabled="true" name="MISRAC++2008-18-0-3" />
                                <check enabled="true" name="MISRAC++2008-18-0-4" />
                                <check enabled="true" name="MISRAC++2008-18-0-5" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check enabled="true" name="MISRAC++2008-18-2-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check enabled="true" name="MISRAC++2008-18-4-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check enabled="true" name="MISRAC++2008-18-7-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check enabled="true" name="MISRAC++2008-19-3-1" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check enabled="true" name="MISRAC++2008-27-0-1" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>Application</name>
        <group>
            <name>Baidu</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\az_platform_STM32Cube.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\az_threadapi_STM32Cube.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\az_tickcounter_STM32Cube.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\az_tlsio_mbedtls_STM32Cube.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\baidu_base64.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\baidu_certs.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\baidu_sha1.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Baidu\Src\socketio_STM32Cube.c</name>
            </file>
        </group>
        <group>
            <name>EWARM</name>
            <file>
                <name>$PROJ_DIR$\startup_stm32l475xx.s</name>
            </file>
        </group>
        <group>
            <name>Shared</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\cloud.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\entropy_hardware_poll.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\flash_l4.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\heap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\http_util.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\iot_flash_config.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\lwip_net.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\mbedtls_net.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\net.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\net_tcp_lwip.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\net_tcp_wifi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\net_tls_mbedtls.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\rfu.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\sensors_data.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\STM32CubeRTCInterface.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\timedate.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\timingSystem.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Common\Shared\Src\wifi_net.c</name>
            </file>
        </group>
        <group>
            <name>User</name>
            <file>
                <name>$PROJ_DIR$\..\Src\iothub_mqtt_client_wifi_sample.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\main.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\stm32l4xx_hal_msp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\stm32l4xx_it.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\vl53l0x_platform.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\vl53l0x_proximity.c</name>
            </file>
        </group>
        <group>
            <name>WiFi</name>
            <file>
                <name>$PROJ_DIR$\..\Src\es_wifi_io.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\tcpsocketSTM32Cube.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Src\wifi.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>Doc</name>
        <file>
            <name>$PROJ_DIR$\..\readme-wifi-package.txt</name>
        </file>
    </group>
    <group>
        <name>Drivers</name>
        <group>
            <name>BSP</name>
            <group>
                <name>B-L475E-IOT01</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_accelero.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_gyro.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_hsensor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_magneto.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_psensor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01\stm32l475e_iot01_tsensor.c</name>
                </file>
            </group>
            <group>
                <name>Components</name>
                <group>
                    <name>ES_WIFI</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\es_wifi\es_wifi.c</name>
                    </file>
                </group>
                <group>
                    <name>HTS221</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\hts221\hts221.c</name>
                    </file>
                </group>
                <group>
                    <name>LIS3MDL</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl\lis3mdl.c</name>
                    </file>
                </group>
                <group>
                    <name>LPS22HB</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb\lps22hb.c</name>
                    </file>
                </group>
                <group>
                    <name>LSM6DSL</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl\lsm6dsl.c</name>
                    </file>
                </group>
                <group>
                    <name>vl53l0x</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_api.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_api_calibration.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_api_core.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_api_ranging.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_api_strings.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x\vl53l0x_platform_log.c</name>
                    </file>
                </group>
            </group>
        </group>
        <group>
            <name>CMSIS</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Source\Templates\system_stm32l4xx.c</name>
            </file>
        </group>
        <group>
            <name>STM32L4xx_HAL_Driver</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cortex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_dma.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_flash.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_flash_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_gpio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_i2c.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_i2c_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rng.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rtc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rtc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_tim.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_tim_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart_ex.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>Middlewares</name>
        <group>
            <name>baidu</name>
            <group>
                <name>c-utility</name>
                <group>
                    <name>adapters</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\adapters\agenttime.c</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\base64.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\buffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\connection_string_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\consolelogger.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\constbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\constmap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\crt_abstractions.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\doublylinkedlist.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\gb_rand.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\gb_stdio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\gb_time.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\gballoc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\hmac.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\hmacsha256.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\http_proxy_io.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\httpapiex.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\httpapiexsas.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\httpheaders.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\map.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\optionhandler.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\sastoken.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\sha1.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\sha224.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\sha384-512.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\singlylinkedlist.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\string_tokenizer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\strings.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_cyclonessl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_cyclonessl_socket.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_cyclonessl_socket_bsd.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_openssl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_schannel.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\tlsio_wolfssl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\urlencode.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\usha.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\utf8_checker.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\uws_client.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\uws_frame_encoder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\vector.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\wsio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\x509_openssl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\x509_schannel.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\xio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\src\xlogging.c</name>
                </file>
            </group>
            <group>
                <name>iothub_client</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\certs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\iotdm_client.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\iothub_client_persistence.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\iothub_client_retry_control.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\iothub_mqtt_client.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\src\version.c</name>
                </file>
            </group>
            <group>
                <name>parson</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\parson\parson.c</name>
                </file>
            </group>
            <group>
                <name>serializer</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\agenttypesystem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\codefirst.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\commanddecoder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\datamarshaller.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\datapublisher.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\dataserializer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\iotdevice.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\jsondecoder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\jsonencoder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\methodreturn.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\multitree.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\schema.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\schemalib.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\src\schemaserializer.c</name>
                </file>
            </group>
            <group>
                <name>umqtt</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\umqtt\src\mqtt_client.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\umqtt\src\mqtt_codec.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\baidu\umqtt\src\mqtt_message.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>mbedTLS</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\aes.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\aesni.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\arc4.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\asn1parse.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\asn1write.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\base64.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\bignum.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\blowfish.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\camellia.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ccm.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\certs.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\cipher.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\cipher_wrap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\cmac.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ctr_drbg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\debug.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\des.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\dhm.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ecdh.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ecdsa.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ecjpake.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ecp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ecp_curves.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\entropy.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\entropy_poll.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\error.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\gcm.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\havege.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\hmac_drbg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\md.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\md2.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\md4.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\md5.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\md_wrap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\memory_buffer_alloc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\net_sockets_template.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\oid.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\padlock.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pem.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pk.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pk_wrap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pkcs11.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pkcs12.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pkcs5.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pkparse.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\pkwrite.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\platform.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ripemd160.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\rsa.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\sha1.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\sha256.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\sha512.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_cache.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_ciphersuites.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_cli.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_cookie.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_srv.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_ticket.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\ssl_tls.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\threading.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\timing.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\version.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\version_features.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509_create.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509_crl.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509_crt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509_csr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509write_crt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\x509write_csr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\library\xtea.c</name>
            </file>
        </group>
    </group>
</project>
