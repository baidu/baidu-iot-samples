# IAR project Project.ewp, settings and files
configuration STM32L496G-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<az_mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; USE_MBED_TLS; _UINTPTR_T; USE_C2C; BAIDU; AZURE; EINVAL=22; ENOMEM=12
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L496G-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Common\Shared\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ../../../../../../Drivers/BSP/Components/ug96; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\certs; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\c-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\parson; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Party\baidu\umqtt\inc; ..\..\..\..\..\Common\Baidu\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: baidu-iothub-c2c.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Baidu
    ../../../../../Common/Baidu/Src/: az_platform_STM32Cube.c az_threadapi_STM32Cube.c az_tickcounter_STM32Cube.c az_tlsio_mbedtls_STM32Cube.c baidu_base64.c baidu_certs.c baidu_sha1.c socketio_STM32Cube.c
  group Application/C2C
    ../Src/: c2c.c tcpsocketSTM32Cube.c ug96_io.c
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Application/Shared
    ../../../../../Common/Shared/Src/: c2c_net.c cloud.c entropy_hardware_poll.c flash_l4.c heap.c http_util.c iot_flash_config.c mbedtls_net.c mbedtls_patch.c net.c net_tcp_c2c.c net_tls_mbedtls.c rfu.c STM32CubeRTCInterface.c timedate.c timer.c timingSystem.c
  group Application/User
    ../Src/: iothub_mqtt_client_c2c_sample.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Doc
    ../: readme-c2c-package.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Middlewares/Third_Party/baidu/c-utility
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/src/: buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gb_rand.c gb_stdio.c gb_time.c gballoc.c hmac.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c utf8_checker.c uws_client.c uws_frame_encoder.c vector.c wsio.c xio.c xlogging.c
  group Middlewares/Third_Party/baidu/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/baidu/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/baidu/iothub_client
    ../../../../../../Middlewares/Third_Party/baidu/iothub_client/src/: iotdm_client.c iothub_client_persistence.c iothub_client_retry_control.c iothub_mqtt_client.c
  group Middlewares/Third_Party/baidu/parson
    ../../../../../../Middlewares/Third_Party/baidu/parson/: parson.c
  group Middlewares/Third_Party/baidu/serializer
    ../../../../../../Middlewares/Third_Party/baidu/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c schemaserializer.c
  group Middlewares/Third_Party/baidu/umqtt
    ../../../../../../Middlewares/Third_Party/baidu/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets_template.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
